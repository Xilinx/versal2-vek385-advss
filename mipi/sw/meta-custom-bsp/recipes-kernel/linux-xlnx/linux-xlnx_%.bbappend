FILESEXTRAPATHS:prepend:versal-2ve-2vm := "${THISDIR}/files:"
SRC_URI:append:versal-2ve-2vm = " file://0001-remoteproc-xlnx-introduce-new-fw-elf-loader.patch "
