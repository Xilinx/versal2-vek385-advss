FILESEXTRAPATHS:prepend:versal-2ve-2vm := "${THISDIR}/files:"
SRC_URI:append:versal-2ve-2vm = " file://0001-v4l-xilinx-vpss-scaler-Add-YUV422-and-YUV420-12-bit-.patch "
