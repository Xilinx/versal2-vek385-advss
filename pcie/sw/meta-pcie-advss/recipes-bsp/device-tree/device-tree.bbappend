FILESEXTRAPATHS:prepend:versal-2ve-2vm-vek385-revb-sdt-seg:linux := "${THISDIR}/files:"
EXTRA_DT_INCLUDE_FILES:append:versal-2ve-2vm-vek385-revb-sdt-seg:linux = " vek385_advss.dtsi"
