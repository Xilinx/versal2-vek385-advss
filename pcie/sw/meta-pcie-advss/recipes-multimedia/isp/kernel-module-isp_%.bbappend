FILESEXTRAPATHS:prepend:versal-2ve-2vm := "${THISDIR}/files:"
SRC_URI:append:versal-2ve-2vm = " file://0001-visp-visp_video-Add-stride-aware-format-handling.patch"
