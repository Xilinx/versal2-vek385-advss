FILESEXTRAPATHS:prepend:versal-2ve-2vm := "${THISDIR}/files:"
SRC_URI:append:versal-2ve-2vm = " file://0001-xilinx-pcie-endpoint-driver-ported-for-kernel-6.12.patch"
